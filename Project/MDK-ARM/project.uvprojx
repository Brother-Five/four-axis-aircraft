# Keil uVision project project.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User\bsp_stm32f4xx\inc;..\..\User\bsp_stm32f4xx;..\..\User;..\..\RTX\inc;..\..\RTX\portable;..\..\MySrc;..\..\Libraries;..\..\MySrc\ostask;..\..\MySrc\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../../User/: main.cpp includes.h RTX_Conf_CM.c
  group BSP
    ../../User/bsp_stm32f4xx/src/: bsp_led.c bsp_hardtimer.c bsp.c bsp_dr16.c bsp_stmflash.c bsp_usart.c
    ../../User/bsp_stm32f4xx/: stm32f4xx_it.c stm32f4xx_assert.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c misc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_crc.c
  group CMSIS
    ../../User/bsp_stm32f4xx/: system_stm32f4xx.c
  group RTX/Source
    ../../RTX/src/: rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group RTX/Ports
    ../../RTX/portable/: HAL_CM4.c rt_HAL_CM.h SVC_Table.s RTX_CM4.lib
  group MySrc
    ../../MySrc/: motor.cpp SystemTimer.c Data_Tramsfer.cpp cpid.cpp DebugTools.cpp DebugToolsConfig.cpp filter.cpp pwm.cpp UsartFrame_STM32.cpp location.c Kalman.cpp Turnplatemotor.cpp
    ../../MySrc/ostask/: os_dr16.cpp
    ../../MySrc/MPU6050/: mpu6050.c myiic.c
  group DSP_Lib
    ../../Libraries/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
